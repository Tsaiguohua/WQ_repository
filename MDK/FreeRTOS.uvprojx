# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407 +hex
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\APP;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\IIC;..\SYSTEM\SPI;..\SYSTEM\rs485;..\Firmware\driver\inc;..\Firmware\driver\src;..\Firmware\cmsis\core;..\Firmware\cmsis\device;..\Third_lib\FreeRTOS\include;..\Third_lib\FreeRTOS\portable\RVDS\ARM_CM4F;..\Driver\AHT20;..\Driver\CDOM;..\Driver\CHL;..\Driver\COD;..\Driver\DO;..\Driver\GPS;..\Driver\LED;..\Driver\PH;..\Driver\SAL;..\Driver\Y4000;..\SYSTEM\Modbus;..\Driver\Buzzer;..\Driver\SelfExam;..\Driver\OLED;..\Driver\Voltage;..\Third_lib\U8g2;..\Driver\Button;..\SYSTEM\Flash;..\Driver\Watchdog;..\SYSTEM\uart4;..\Driver\OTA;..\Driver\W25Q128;..\User;..\User\Tasks;..\User\MidFunc;..\Third_lib\FatFs;..\Driver\TF;..\SYSTEM\sdio_sdcard
  memory RVCT4: ROM 0x8080000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: main.c version.c stm32f4xx_it.c system_stm32f4xx.c
  group User/Tasks
    ../User/Tasks/: TasksInit.c HardwareInitTask.c AcqTask.c UpLoadTask.c CommandTask.c GPSTask.c OLEDTask.c HeartBeatTask.c TFTask.c
  group User/MidFunc
    ../User/MidFunc/: WQInterface.c
  group Driver
    ../Driver/COD/: cod.c
    ../Driver/CDOM/: cdom.c
    ../Driver/CHL/: chl.c
    ../Driver/PH/: ph.c
    ../Driver/DO/: do.c
    ../Driver/SAL/: sal.c
    ../Driver/Y4000/: y4000.c
    ../Driver/AHT20/: aht20.c
    ../Driver/GPS/: gps.c
    ../Driver/LED/: led.c
    ../Driver/OLED/: oled.c
    ../Driver/Buzzer/: buzzer.c
    ../Driver/Button/: button.c
    ../Driver/Voltage/: voltage.c
    ../Driver/SelfExam/: self_exam.c
    ../Driver/Watchdog/: watchdog.c
    ../Driver/OTA/: ota.c
    ../Driver/W25Q128/: w25q128.c
    ../Driver/TF/: TF.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/IIC/: iic.c
    ../SYSTEM/SPI/: spi.c
    ../SYSTEM/rs485/: rs485.c
    ../SYSTEM/Modbus/: modbus.c
    ../SYSTEM/Flash/: flash.c
    ../SYSTEM/uart4/: uart4.c
    ../SYSTEM/sdio_sdcard/: sdio_sdcard.c
  group Firmware
    ../Firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_sai.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../Firmware/cmsis/device/: startup_stm32f40_41xxx.s
  group Third_lib
    ../Third_lib/FreeRTOS/: list.c queue.c tasks.c timers.c
    ../Third_lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../Third_lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../Third_lib/FreeRTOS/include/: FreeRTOSConfig.h
    ../Third_lib/U8g2/: mui.c mui_u8g2.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group FatFs
    ../Third_lib/FatFs/: diskio.c ff.c
